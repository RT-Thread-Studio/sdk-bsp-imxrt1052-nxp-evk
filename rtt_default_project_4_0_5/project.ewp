# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6A NXP MIMXRT1052xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MIMXRT1052DVL6B; SKIP_SYSCLK_INIT; EVK_MCIMXRM; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; XIP_EXTERNAL_FLASH=1; __RTTHREAD__; RT_USING_DLIBC
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..\..\..\components\finsh; ..\..\..\components\drivers\include; ..\..\..\components\libc\compilers\common\nogcc; ..\..\..\components\libc\compilers\dlib; ..\libraries\MIMXRT1050\MIMXRT1052; ..\..\..\components\libc\compilers\common; ..\libraries\drivers; ..\..\..\examples\utest\testcases\kernel; .; xip; board; ..\libraries\MIMXRT1050\CMSIS\Include; board\MCUX_Config; board\ports; ..\libraries\drivers\config; applications; ..\libraries\peripherals; ..\..\..\include; ..\..\..\libcpu\arm\common; ..\..\..\libcpu\arm\cortex-m7; ..\..\..\components\net\netdev\include; ..\libraries\MIMXRT1050\MIMXRT1052\drivers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Applications
    applications/: mnt.c main.c
  group CPU
    ../../../libcpu/arm/common/: showmem.c backtrace.c div0.c
    ../../../libcpu/arm/cortex-m7/: context_iar.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../../../components/drivers/cputime/: cputime.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/phy/: phy.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: waitqueue.c ringblk_buf.c dataqueue.c completion.c pipe.c ringbuffer.c workqueue.c
  group Drivers
    board/MCUX_Config/: pin_mux.c clock_config.c
    board/: board.c
    ../libraries/drivers/: drv_gpio.c drv_uart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: device.c memheap.c scheduler.c irq.c object.c ipc.c clock.c mempool.c idle.c thread.c components.c timer.c kservice.c
  group libc
    ../../../components/libc/compilers/common/: time.c stdlib.c
    ../../../components/libc/compilers/dlib/: stdio.c syscall_mem.c syscall_open.c syscall_read.c syscall_close.c syscall_write.c syscalls.c libc.c environ.c syscall_lseek.c syscall_remove.c
  group Libraries
    ../libraries/MIMXRT1050/MIMXRT1052/: system_MIMXRT1052.c
    ../libraries/MIMXRT1050/MIMXRT1052/drivers/: fsl_gpio.c fsl_lpuart.c fsl_clock.c fsl_cache.c fsl_common.c
    ../libraries/MIMXRT1050/MIMXRT1052/iar/: startup_MIMXRT1052.s
  group SAL
    ../../../components/net/netdev/src/: netdev_ipaddr.c netdev.c
  group xip
    xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_flash.c
